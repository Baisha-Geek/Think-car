# IAR project 智能小车控制.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; CMSIS\; FWLIB\inc\; USER\; DRIVER\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 智能小车控制.hex
  ILINK.IlinkOutputFile: 智能小车控制.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/startup
    CMSIS/startup/iar/: startup_stm32f10x_hd.s
  group CMSIS/system
    CMSIS/: system_stm32f10x.c
  group DRIVER
    DRIVER/src/: dianji.c naodianbo.c TIM.c yuyin.c
  group FWLIB
    FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    USER/: main.c stm32f10x_it.c
